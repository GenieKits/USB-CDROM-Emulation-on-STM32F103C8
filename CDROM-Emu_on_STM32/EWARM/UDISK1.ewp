# IAR project UDISK1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xB
  ICCARM.CCIncludePath2: ..\MAIN\Inc; ..\CMSIS\Include; ..\CMSIS\Device\STM32F1xx\Include; ..\HAL\Inc; ..\HAL\Inc\Legacy; ..\USB\Class\Inc; ..\USB\Core\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: UDISK1.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F103xB
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: UDISK1.hex
  group CMSIS/Device
    ../CMSIS/Device/STM32F1xx/Include/: stm32f103xb.h stm32f1xx.h system_stm32f1xx.h
  group CMSIS/Include
    ../CMSIS/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
  group HAL/Inc
    ../HAL/Inc/: stm32f1xx_hal.h stm32f1xx_hal_cortex.h stm32f1xx_hal_def.h stm32f1xx_hal_dma.h stm32f1xx_hal_dma_ex.h stm32f1xx_hal_exti.h stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_pcd.h stm32f1xx_hal_pcd_ex.h stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_spi.h stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.h stm32f1xx_ll_usb.h
  group HAL/Inc/legacy
    ../HAL/Inc/Legacy/: stm32_hal_legacy.h
  group HAL/Src
    ../HAL/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_usb.c
  group MAIN
    ./: cstartup.c
  group MAIN/Inc
    ../MAIN/Inc/: main.h spiflash.h stm32f1xx_hal_conf.h stm32f1xx_it.h usb_device.h usbd_conf.h usbd_desc.h usbd_storage_if.h
  group MAIN/Src
    ../MAIN/Src/: main.c spiflash.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c usb_device.c usbd_conf.c usbd_desc.c usbd_storage_if.c
  group USB/Class/Inc
    ../USB/Class/Inc/: usbd_msc.h usbd_msc_bot.h usbd_msc_data.h usbd_msc_scsi.h
  group USB/Class/Src
    ../USB/Class/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group USB/Core/Inc
    ../USB/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
  group USB/Core/Src
    ../USB/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
