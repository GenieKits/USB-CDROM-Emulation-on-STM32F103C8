# Keil uVision project UDISK1.uvprojx, settings and files
target UDISK1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UDISK1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB
  c include: ..\MAIN\Inc;..\CMSIS\Include;..\CMSIS\Device\STM32F1xx\Include;..\HAL\Inc;..\USB\Class\Inc;..\USB\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MAIN
    ../MAIN/Src/: main.c spiflash.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c usb_device.c usbd_conf.c usbd_desc.c usbd_storage_if.c
    ./RTE/Device/STM32F103C8/: startup_stm32f10x_md.s
  group HAL
    ../HAL/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_usb.c
  group USB
    ../USB/Class/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
    ../USB/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
